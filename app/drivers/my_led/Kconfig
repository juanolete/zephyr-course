## boards/our_board/board.yml
```yaml
board:
  name: our_board
  full_name: our_board (nRF51 Dongle)
  vendor: nordic
  socs:
  - name: nrf51822
```
